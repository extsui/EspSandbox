# Repository extsui/EspSandbox

## KiCad design Circuits/Rustorch/Rustorch.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_PS_RP2_C13_40
C1, C2: 47u; CP_Radial_D5.0mm_P2.50mm
C3: 0.1u; C_Disc_D3.0mm_W2.0mm_P2.50mm
CN1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
CN2: OLED_128x64_IIC; OLED_128x64_0.96inch
D1, D3, D4, D5, D6, D7, D8: 1N4148; D_DO-35_SOD27_P5.08mm_Vertical_AnodeUp
D2: LED_POWER; LED_D3.0mm
Q1, Q2, Q3, Q4: 2SC1815; TO-92_Inline
R1, R2, R5, R6: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4, R7, R8, R9: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10, R11: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12, R13, R14, R15, R16, R17, R18, R19: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R20, R21, R22, R23: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RV1: R_Potentiometer_Small; TSR_3386T
SW1: ToggleSW 3P; PinSocket_1x05_P2.54mm_Vertical
SW2: RESET; SW_PUSH_6mm_H7.3mm
SW3: SW_BOOT; SW_PUSH_6mm_H7.3mm
SW4: SW_UP; SW_PUSH_6mm_H7.3mm
SW5: SW_LEFT; SW_PUSH_6mm_H7.3mm
SW6: SW_RIGHT; SW_PUSH_6mm_H7.3mm
SW7: SW_DOWN; SW_PUSH_6mm_H7.3mm
SW8: SW_A; SW_PUSH_6mm_H7.3mm
SW9: SW_B; SW_PUSH_6mm_H7.3mm
U1: ESP32-C6-WROOM-1
U2: BA033CC0T; TO-220-3_Vertical
U3, U4, U5, U6: OSL10561-L*; 7SegmentLED_LTS6760_LTS6780

Connections:
7SEG_A: R12.1, U1.19 (GPIO21)
7SEG_B: R13.1, U1.20 (GPIO22)
7SEG_C: R14.1, U1.21 (GPIO23)
7SEG_D: R15.1, U1.23 (GPIO15)
7SEG_DIGIT1: R20.1, U1.12 (GPIO11)
7SEG_DIGIT2: R21.1, U1.16 (GPIO18)
7SEG_DIGIT3: R22.1, U1.17 (GPIO19)
7SEG_DIGIT4: R23.1, U1.18 (GPIO20)
7SEG_DP: R19.1, U1.27 (GPIO2/ADC1_CH2)
7SEG_E: R16.1, U1.24 (U0RXD/GPIO17)
7SEG_F: R17.1, U1.25 (U0TXD/GPIO16)
7SEG_G: R18.1, U1.26 (GPIO3/ADC1_CH3)
+3.3V: C2.1, C3.1, CN2.2, D1.2 (A), R4.2, R5.2, R6.2, R8.2, R9.2, RV1.3, U1.2 (3V3), U2.3 (VO)
+5V: C1.1, D1.1 (K), R3.2, SW1.4, U2.1 (VI)
/A: R12.2, U3.7 (A), U4.7 (A), U5.7 (A), U6.7 (A)
/B: R13.2, U3.6 (B), U4.6 (B), U5.6 (B), U6.6 (B)
/C: R14.2, U3.4 (C), U4.4 (C), U5.4 (C), U6.4 (C)
/D: R15.2, U3.2 (D), U4.2 (D), U5.2 (D), U6.2 (D)
/DP: R19.2, U3.5 (DP), U4.5 (DP), U5.5 (DP), U6.5 (DP)
/E: R16.2, U3.1 (E), U4.1 (E), U5.1 (E), U6.1 (E)
/F: R17.2, U3.9 (F), U4.9 (F), U5.9 (F), U6.9 (F)
/G: R18.2, U3.10 (G), U4.10 (G), U5.10 (G), U6.10 (G)
GND: BZ1.2 (-), C1.2, C2.2, C3.2, CN1.A1 (GND), CN1.A12 (GND), CN1.B1 (GND), CN1.B12 (GND), CN1.S1 (SHIELD), CN2.1, D2.1 (K), Q1.1 (E), Q2.1 (E), Q3.1 (E), Q4.1 (E), R1.2, R2.2, RV1.1, SW2.1, SW3.1, U1.1 (GND), U1.28 (GND), U1.29 (GND), U2.2 (GND)
KEY_IN1_IO9_BOOT: D3.2 (A), D4.2 (A), R8.1, SW3.2, U1.15 (GPIO9)
KEY_IN2: D5.2 (A), D6.2 (A), U1.11 (GPIO10)
KEY_IN3_IO8: D7.2 (A), D8.2 (A), R9.1, U1.10 (GPIO8)
KEY_OUT1: R10.2, U1.9 (GPIO1/ADC1_CH1/XTAL_32K_N)
KEY_OUT2: R11.2, U1.8 (GPIO0/ADC1_CH0/XTAL_32K_P)
unnamed: BZ1.1 (+), R7.2
unnamed: CN1.A5 (CC1), R1.1
unnamed: CN1.B5 (CC2), R2.1
unnamed: D2.2 (A), R3.1
unnamed: D3.1 (K), SW4.1
unnamed: D4.1 (K), SW5.1
unnamed: D5.1 (K), SW6.1
unnamed: D6.1 (K), SW7.1
unnamed: D7.1 (K), SW8.1
unnamed: D8.1 (K), SW9.1
unnamed: Q1.3 (B), R20.2
unnamed: Q1.2 (C), U3.3 (CC)
unnamed: Q2.3 (B), R21.2
unnamed: Q2.2 (C), U4.3 (CC)
unnamed: Q3.3 (B), R22.2
unnamed: Q3.2 (C), U5.3 (CC)
unnamed: Q4.3 (B), R23.2
unnamed: Q4.2 (C), U6.3 (CC)
unnamed: R10.1, SW4.2, SW6.2, SW8.2
unnamed: R11.1, SW5.2, SW7.2, SW9.2
unnamed: R4.1, SW2.2, U1.3 (EN/CHIP_PU)
unnamed: RV1.2, U1.5 (MTDI/GPIO5/ADC1_CH5)
unnamed: R7.1, U1.4 (MTMS/GPIO4/ADC1_CH4)
SCL: CN2.3, R6.1, U1.7 (MTDO/GPIO7)
SDA: CN2.4, R5.1, U1.6 (MTCK/GPIO6/ADC1_CH6)
USB_D+: CN1.A6 (D+), CN1.B6 (D+), U1.14 (GPIO13/USB_D+)
USB_D-: CN1.A7 (D-), CN1.B7 (D-), U1.13 (GPIO12/USB_D-)
VBUS: CN1.A4 (VBUS), CN1.A9 (VBUS), CN1.B4 (VBUS), CN1.B9 (VBUS), SW1.3

Notes on the sheet:
スイッチを上に押したときに ON になるようにピン配置した
三端子レギュレータは以下のいずれかを使用する予定 * BA033CC0T (3.3V1A, モールド) \100 * LM2940T-3.3 (3.3V1A, 非モールド) \60 ※NJU7223 はピン配置が異なるので使用不可
電流制限抵抗の抵抗値は暫定 (候補: 330Ω or 100Ω)
KEY_IN2 は内蔵プルアップを使用
IO9=0 & IO8=1 の時に Download Mode になる このため IO8 にプルアップ抵抗を入れておく
7セグメントLEDの色は実際のVfを見つつ決める 基本的に赤想定で青/緑/白は厳しめかも
* BOOT SW 押下時にキースキャン用の出力が GND 直結になるのを防止する用に直列抵抗を入れる * IO8/IO9 のプルアップ抵抗 10k との 分圧を考えて直列抵抗は 1k にしておく (ダイオードがあるので不要かもしれないが念のため)

Board: 2 copper layers, 95.0 x 71.9 mm, 57 parts (0 on the bottom side), 56 nets.

## Code that names these connections

File Samples/rustorch/src/main.rs (part):

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    let led_driver = Arc::new(Mutex::new(LedDriver::new()));
    {
        let led_pins = LedPins {
            seg_a: peripherals.pins.gpio21.downgrade_output(),
            seg_b: peripherals.pins.gpio22.downgrade_output(),
            seg_c: peripherals.pins.gpio23.downgrade_output(),
            seg_d: peripherals.pins.gpio15.downgrade_output(),
            seg_e: peripherals.pins.gpio17.downgrade_output(),
            seg_f: peripherals.pins.gpio16.downgrade_output(),
            seg_g: peripherals.pins.gpio3.downgrade_output(),
            seg_dot: peripherals.pins.gpio2.downgrade_output(),
            seg_digit1: peripherals.pins.gpio11.downgrade_output(),
            seg_digit2: peripherals.pins.gpio18.downgrade_output(),
            seg_digit3: peripherals.pins.gpio19.downgrade_output(),
            seg_digit4: peripherals.pins.gpio20.downgrade_output(),
        };
        let led_driver_clone = Arc::clone(&led_driver);
        led_driver_clone.lock().unwrap().start_dynamic_lighting(led_pins, peripherals.timer10)?;
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    let key_matrix = Arc::new(Mutex::new(KeyMatrix::new()));
    {
        let key_matrix_pins = KeyMatrixPins {
            key_in1: peripherals.pins.gpio9.downgrade_input(),
            key_in2: peripherals.pins.gpio10.downgrade_input(),
            key_in3: peripherals.pins.gpio8.downgrade_input(),
            key_out1: peripherals.pins.gpio1.downgrade_output(),
            key_out2: peripherals.pins.gpio0.downgrade_output(),
        };
        let key_matrix_clone = Arc::clone(&key_matrix);
        key_matrix_clone.lock().unwrap().start_scan(key_matrix_pins)?;
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    let display_driver = Arc::new(Mutex::new(DisplayDriver::new()));
    {
        let i2c0 = peripherals.i2c0;
        let sda = peripherals.pins.gpio6;
        let scl = peripherals.pins.gpio7;
        let display_driver_clone = Arc::clone(&display_driver);
        display_driver_clone.lock().unwrap().start_thread(i2c0, sda, scl)?;
        {
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
    let buzzer_driver = Arc::new(Mutex::new(BuzzerDriver::new()));
    {
        let buzzer_pin = peripherals.pins.gpio4;
        let channel0 = peripherals.ledc.channel0;
        let timer0 = peripherals.ledc.timer0;
        let buzzer_driver_clone = Arc::clone(&buzzer_driver);
        buzzer_driver_clone.lock().unwrap().start_thread(buzzer_pin, channel0, timer0)?;
    }

    let volume = Arc::new(Mutex::new(Volume::new(peripherals.adc1, peripherals.pins.gpio5)));

    let context = AppContext {
        button: key_matrix,
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
## Commit log

2024-05-12 ESP32NOW の Master/Slave サンプルの動作確認
2024-05-12 ESP32NOW の Master/Slave サンプルの最低限のコード整備
2024-06-03 ABORT 時にバックトレースを表示するように修正
2024-06-03 送受信データの16進数ダンプを追加
2024-06-03 デバッガの有効化
2024-06-03 Serial.begin() 直後にログを出すと不安定になるので暫定で待ちを追加
2024-06-03 Fountain プロジェクトを作成
2024-06-03 (Fountain) DIPSW を自身のアドレスとして使用できる機能を追加
2024-06-03 (Fountain) 起動時のメロディを追加
2024-06-11 (Fountain) 64byte のブロードキャスト送信を実装
2024-06-17 (Fountain) GardeningBoard のコードを一部移植
2024-06-17 (Fountain) Building を点灯させる最低限のプログラムを移植
2024-06-20 (Fountain) 子機側の受信処理を追加
2024-06-20 (Fountain) Building の処理をクラス内に移動
2024-06-20 (Fountain) 親機から表示データを送信して子機で受信したデータを表示するように修正
2024-06-20 (Fountain) Volume の処理を移植
2024-06-20 (Fountain) Button の処理を移植
2024-06-20 (Fountain) パケット構造を定義して輝度も送受信対象に追加
2024-06-23 (Fountain) WiFi チャネルをビルド時に選択できるように修正
2024-08-04 (KiCad) v8 向け共通ライブラリを登録
2024-08-04 (Rustorch) KiCad プロジェクト作成
2024-08-04 (Rustorch) 回路図部品配置中
2024-08-04 (Rustorch) 回路図修正 (7セグ部分追加)
2024-08-13 (Rustorch) 回路図修正 (キーマトリクス追加)
2024-08-13 (Rustorch) 回路図修正 (アノテーションのエラー/警告に対処)
    * バス接続エラー：7SEG のバスにグループラベル {A B ... DP} を付与することで解決
    * 電源ラベルエラー：グローバルラベル3V3 と電源の +3.3V が衝突していたので +3.3V に統一
    * 電源出力衝突エラー：3端子レギュレータ VO に PWR_FLAG を付与した +3.3V を接続していてエラーになったので PWR_FLAG を除去
2024-08-13 (Rustorch) 回路図修正 (部品番号の振り直し)
2024-08-13 (Rustorch) 回路図修正 (三端子レギュレータ VI のコンデンサを電解に修正)
2024-08-13 (Rustorch) 回路図フットプリント割り当て (可変抵抗は未)
2024-08-14 (Rustorch) 可変抵抗 TSR-3386T のフットプリントを追加
2024-08-14 (Fountain) パケロス対策にパケットを毎回2回送信するように修正
2024-08-15 (Rustorch) 基板に部品を仮配置
2024-08-15 (Rustorch) 基板の電源スイッチを修正
2024-08-18 (Rustorch) 配線作業 (4層化)
2024-08-19 (Rustorch) 配線作業 (7セグ周辺)
2024-08-19 (Rustorch) 配線作業 (一通り接続完了した状態)
2024-08-20 (Rustorch) 配線作業 (表面に配線を集約中)
2024-08-20 (Rustorch) 配線作業 (MCU 裏の配線調整中)
2024-08-20 (Rustorch) 配線作業 (MCU 周辺の裏面側配線を整理)
2024-08-22 (Rustorch) 配線作業 (4層から2層に削減するための準備)
2024-08-24 (Rustorch) 配線作業 (配線を2層に削減可能な状態へ修正)
2024-08-24 (Rustorch) 配線作業 (配線を2層化)
2024-08-24 (Rustorch) 配線作業 (GND ビア打ち)
2024-08-24 (Rustorch) 配線作業 (Teardrop 追加)
2024-08-24 (Rustorch) 配線作業 (DRC エラーの対処)
2024-08-24 (Rustorch) 配線作業 (プロジェクト名・作者名のシルクを追加)
2024-08-24 (Rustorch) ガーバー v1.0 作成
2024-09-01 (Rustorch) Rust プロジェクト作成
2024-09-01 (Rustorch) ダイナミック点灯の動作確認
    * delay_ms() の待ち時間が適切になっていなさそうだったので FreeRTOS の HZ を 100 -> 1k に修正
2024-09-01 (Rustorch) 7セグの数字表示確認
2024-09-19 (Rustorch) ダイナミック点灯をスレッドに分離
    * gpioX.downgrade_output() で抽象化した gpio を扱えるように修正
2024-09-24 (Rustorch) キースキャンスレッドを作成
2024-09-28 (Rustorch) ブザー鳴動の動作確認
2024-09-28 (Rustorch) キースキャン処理を crate に移動
2024-09-28 (Rustorch) ダイナミック点灯を crate に移動
2024-09-28 (Rustorch) ボタン押下とブザー鳴動を連動
2024-10-02 (Rustorch) ADC のテストコード追加
2024-10-02 (Rustorch) ADC の結果とブザーのオクターブを連動
2024-10-03 (Rustorch) 7セグ表示をメインスレッドから指定できるように修正
2024-10-05 (Rustorch) refactor: ソースコードを分割
2024-10-06 (Rustorch) SSD1306 の動作確認
2024-10-06 (Rustorch) embedded-graphics を導入
2024-10-09 (Rustorch) embedded-graphics と ssd1306 を使用するスレッド用にスタックサイズを増量
2024-10-31 (Rustorch) 60fps を刻むためのベースコードを作成
2024-11-02 (Rustorch) KeyMatrix のボタンのビット定義を追加および AB ボタンが逆になっていたのを修正
2024-11-02 (Rustorch) KeyMatrix にボタン離しイベント取得を追加
2024-11-02 (Rustorch) スロットマシンの最低限の機能を実装
2024-11-07 (Rustorch) スロットマシンの回転アニメーションを試作
2024-11-07 (Rustorch) スロットマシンの回転アニメーション速度を上下キーで動的に更新
2024-11-07 (Rustorch) スロットマシンのアニメーションを浮き出るような形式に修正
2024-11-11 (Rustorch) ポモドーロタイマの作成に着手
2024-11-11 (Rustorch) ポモドーロタイマの状態遷移を実装
2024-11-13 (Rustorch) 7セグ輝度調整をハードウェアタイマと周期タスクで実現
2024-11-15 (Rustorch) 画面描画スレッドの優先度下げとタスク表示対応
2024-11-17 (Rustorch) 白黒ビットマップ描画の実験
2024-11-17 (Rustorch) DisplayDriver モジュールを別ファイル化
2024-11-18 (Rustorch) DisplayDriver を mpsc を使用した実装に修正
2024-11-18 (Rustorch) DisplayDriver に draw_image() を実装
    画像引数は埋め込んだバイナリを指定するので &'static [u8] を指定
2024-12-07 (Rustorch) ブザードライバのベースを作成
2024-12-07 (Rustorch) 簡易ピアノのフレーム周期の中に移動
2024-12-08 (Rustorch) ボリューム関連を完全隠蔽でモジュール化
2024-12-08 (Rustorch) アプリの入出力をまとめた構造体を作成
2024-12-08 (Rustorch) AppFramework を定義して既存アプリを外出し (ToyPiano のみ)
2024-12-08 (Rustorch) 既存アプリ (ポモドーロタイマ) の外出し
2024-12-08 (Rustorch) 既存アプリ (スロットゲーム) の外出し
2024-12-08 (Rustorch) メニュー画面の試作
2024-12-09 (Rustorch) 全ボタン押しでメニューに戻った後に反応無し状態を追加
2024-12-09 (Rustorch) AppFramework に initialize()/finalize() を整備
2024-12-09 (Rustorch) 簡易ピアノ終了時に音が鳴り続けないように対処
2024-12-11 (Rustorch) (test) テストプロジェクトを作成
2024-12-11 (Rustorch) (test) LedDriver::parse のテストを作成
2024-12-11 (Rustorch) 7セグ表示の文字列指定 API を追加
2024-12-11 (Rustorch) 7セグ表示処理を文字列指定 API に一部置換
2024-12-11 (Rustorch) メニュー画面に7セグカウンタと輝度調整を追加
2024-12-16 (Rustorch) フレーム誤差が蓄積しないように修正
2024-12-16 (Rustorch) ポモドーロタイマ起動画面を追加
